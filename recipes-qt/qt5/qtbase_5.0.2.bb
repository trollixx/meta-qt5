require ${PN}.inc
require qt5-${PV}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c1800c0680fe6185cdc29ea9f5dfeb4b"
SRC_URI[sha256sum] = "1f64f5fbe186be725e9570548c45447121d1658cd9f6c7ba8f30f30f83944685"
