require ${PN}.inc
require qt5-5.0.2+git.inc

PR = "${INC_PR}.0"

SRCREV = "8f125985dbebef9ab9db31e8a180d01b7452030e"
