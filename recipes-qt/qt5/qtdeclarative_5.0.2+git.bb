require ${PN}.inc
require qt5-5.0.2+git.inc

PR = "${INC_PR}.0"

SRCREV = "4d54326fece7fe915902e3bbac34aa0e2569f219"
