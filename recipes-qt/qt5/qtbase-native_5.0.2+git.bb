require ${PN}.inc
require qt5-5.0.2+git.inc

PR = "${INC_PR}.0"

DEFAULT_PREFERENCE = "-1"

SRCREV = "448c3e85dddbfc5c101aceeeceb8584a3d41c913"
